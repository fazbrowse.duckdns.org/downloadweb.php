PROGRAM PRG_TEST
VAR
	fbSum_Test : FB_Sum_Test;
END_VAR

TcUnit.RUN();

END_PROGRAM
