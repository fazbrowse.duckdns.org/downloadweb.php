FUNCTION_BLOCK FB_Sum_Test EXTENDS TcUnit.FB_TestSuite
VAR
END_VAR

TwoPlusTwoEqualsFour();
ZeroPlusZeroEqualsZero();

METHOD PRIVATE TwoPlusTwoEqualsFour
VAR
	Sum : FB_Sum;
	Result : UINT;
    ExpectedSum : UINT := 4;
END_VAR
TEST('TwoPlusTwoEqualsFour');

Sum(one := 2, two := 2, result => Result);

AssertEquals(Expected := ExpectedSum,
             Actual := Result,
             Message := 'The calculation is not correct');

TEST_FINISHED();
END_METHOD

METHOD PRIVATE ZeroPlusZeroEqualsZero
VAR
	Sum : FB_Sum;
	Result : UINT;
    ExpectedSum : UINT := 0;
END_VAR
TEST('ZeroPlusZeroEqualsZero');

Sum(one := 0, two := 0, result => Result);

AssertEquals(Expected := ExpectedSum,
             Actual := Result,
             Message := 'The calculation is not correct');

TEST_FINISHED();
END_METHOD

END_FUNCTION_BLOCK
