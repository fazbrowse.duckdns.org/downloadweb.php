FUNCTION_BLOCK FB_Sum
VAR_INPUT
	one : UINT;
	two : UINT;
END_VAR
VAR_OUTPUT
	result : UINT;
END_VAR

result := one + two;

END_FUNCTION_BLOCK
