FUNCTION F_WORDFromBytes : WORD
VAR_INPUT
    B1 : BYTE;
    B0 : BYTE;
END_VAR

F_WORDFromBytes := SHL(BYTE_TO_WORD(B1),8) OR BYTE_TO_WORD(B0);

END_FUNCTION
