(*
    This function block parses a the part "text identity" of the diagnostic message according to the
    ETG.1020 protocol enhancements. This is the text identity according to the ESI-file.
*)
FUNCTION_BLOCK FB_DiagnosticMessageTextIdentityParser
VAR_INPUT
    anTextIdentityBuffer : ARRAY[1..2] OF BYTE;
END_VAR
VAR_OUTPUT
    nTextIdentity : UINT;
END_VAR

nTextIdentity := WORD_TO_UINT(F_WORDFromBytes(B1 := anTextIdentityBuffer[2], B0 := anTextIdentityBuffer[1]));

END_FUNCTION_BLOCK
