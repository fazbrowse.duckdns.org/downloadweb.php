{attribute 'qualified_only'}
// These variables only exist to test the TcUnit framework. You can ignore them.
VAR_GLOBAL
    nTimedFunctionBlockTestShortTime : ULINT;
    nTimedFunctionBlockTestLongTime : ULINT;
    nStateMachineFunctionBlockTestVariant100 : ULINT;
    nStateMachineFunctionBlockTestVariant50 : ULINT;
    nStateMachineFunctionBlockTestVariant20 : ULINT;
END_VAR
