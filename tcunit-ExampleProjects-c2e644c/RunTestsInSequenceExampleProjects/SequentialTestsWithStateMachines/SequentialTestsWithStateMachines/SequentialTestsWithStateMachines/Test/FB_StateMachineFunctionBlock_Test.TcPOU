FUNCTION_BLOCK FB_StateMachineFunctionBlock_Test EXTENDS TcUnit.FB_TestSuite

(* The tests are run in the order that they are called. Asserts are not evaluated before the previous test has called TEST_FINISHED() *)
TestVariant100();
TestVariant50();
TestVariant20(); // This test will fail

METHOD PRIVATE TestVariant100
(* We need to declare the FB_StateMachineFunctionBlock as an instance variable,
   as it needs to hold its values over several cycles *)
VAR_INST
    // Function block under test
    fbStateMachineFunctionBlock : FB_StateMachineFunctionBlock;
    fbTon : TON := (PT := T#5S); // The maximum time we will run the test
END_VAR
VAR CONSTANT
    EXPECTED_RESULT : INT := 100;
END_VAR
// Make sure to only run test logic if it's time for this test to execute
IF TEST_ORDERED('TestVariant100') THEN
    GVL.nStateMachineFunctionBlockTestVariant100 := GVL.nStateMachineFunctionBlockTestVariant100 + 1; // Only for testing the framework. Ignore this.
    fbTon(IN := TRUE); // Maximum time we will run the test
    fbStateMachineFunctionBlock(bStart := TRUE, nVariant := 100);
    (* Check if we get a timeout or if we get the result we want *)
    IF fbTon.Q OR fbStateMachineFunctionBlock.nValue = EXPECTED_RESULT THEN
        AssertEquals_INT(Expected := EXPECTED_RESULT,
                         Actual := fbStateMachineFunctionBlock.nValue,
                         Message := 'Value not correct');
        TEST_FINISHED();
	END_IF
END_IF
END_METHOD

METHOD PRIVATE TestVariant20
(* We need to declare the FB_StateMachineFunctionBlock as an instance variable,
   as it needs to hold its values over several cycles *)
VAR_INST
    // Function block under test
    fbStateMachineFunctionBlock : FB_StateMachineFunctionBlock;
    fbTon : TON := (PT := T#1MS); // The maximum time we will run the test
END_VAR
VAR CONSTANT
    EXPECTED_RESULT : INT := 100;
END_VAR
// Make sure to only run test logic if it's time for this test to execute
// Note that this test will fail, as we will not run it long enough to get the correct result! *)
IF TEST_ORDERED('TestVariant20') THEN
    GVL.nStateMachineFunctionBlockTestVariant20 := GVL.nStateMachineFunctionBlockTestVariant20 + 1; // Only for testing the framework. Ignore this.
    fbTon(IN := TRUE); // Maximum time we will run the test
    fbStateMachineFunctionBlock(bStart := TRUE, nVariant := 20);
    (* Check if we get a timeout or if we get the result we want *)
    IF fbTon.Q OR fbStateMachineFunctionBlock.nValue = EXPECTED_RESULT THEN
        AssertEquals_INT(Expected := EXPECTED_RESULT,
                         Actual := fbStateMachineFunctionBlock.nValue,
                         Message := 'Value not correct');
        TEST_FINISHED();
	END_IF
END_IF
END_METHOD

METHOD PRIVATE TestVariant50
(* We need to declare the FB_StateMachineFunctionBlock as an instance variable,
   as it needs to hold its values over several cycles *)
VAR_INST
    // Function block under test
    fbStateMachineFunctionBlock : FB_StateMachineFunctionBlock;
    fbTon : TON := (PT := T#5S); // The maximum time we will run the test
END_VAR
VAR CONSTANT
    EXPECTED_RESULT : INT := 200;
END_VAR
// Make sure to only run test logic if it's time for this test to execute
IF TEST_ORDERED('TestVariant50') THEN
    GVL.nStateMachineFunctionBlockTestVariant50 := GVL.nStateMachineFunctionBlockTestVariant50 + 1; // Only for testing the framework. Ignore this.
    fbTon(IN := TRUE); // Maximum time we will run the test
    fbStateMachineFunctionBlock(bStart := TRUE, nVariant := 50);
    (* Check if we get a timeout or if we get the result we want *)
    IF fbTon.Q OR fbStateMachineFunctionBlock.nValue = EXPECTED_RESULT THEN
        AssertEquals_INT(Expected := EXPECTED_RESULT,
                         Actual := fbStateMachineFunctionBlock.nValue,
                         Message := 'Value not correct');
        TEST_FINISHED();
	END_IF
END_IF
END_METHOD

END_FUNCTION_BLOCK
