FUNCTION_BLOCK FB_DiagnosticMessageTextIdentityParser_Test EXTENDS TcUnit.FB_TestSuite

(* The tests are run in the order that they are called. Asserts are not evaluated before the previous test has called TEST_FINISHED() *)
WhenTextIdentityLowExpectTextIdentity0();
WhenTextIdentityHighExpectTextIdentity65535();
WhenTextIdentityMedExpectTextIdentity34500();

METHOD PRIVATE WhenTextIdentityHighExpectTextIdentity65535
VAR
    fbDiagnosticMessageTextIdentityParser : FB_DiagnosticMessageTextIdentityParser;
    nTextIdentity : UINT;

    // @TEST-FIXTURE TextIdentity#High
    cnTextIdentityBufferByte1_IdentityHigh : BYTE := 16#FF; // 0xFFFF = 65535
    cnTextIdentityBufferByte2_IdentityHigh : BYTE := 16#FF;
    canTextIdentityBuffer_IdentityHigh : ARRAY[1..2] OF BYTE := [cnTextIdentityBufferByte1_IdentityHigh,
                                                                 cnTextIdentityBufferByte2_IdentityHigh];
    // @TEST-RESULT TextIdentity#High
    cnTextIdentity_IdentityHigh : UINT := 65535;
END_VAR
IF TEST_ORDERED('WhenTextIdentityHighExpectTextIdentity65535') THEN
    GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityHighExpectTextIdentity65535 := GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityHighExpectTextIdentity65535 + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageTextIdentityParser(anTextIdentityBuffer := canTextIdentityBuffer_IdentityHigh,
                                          nTextIdentity => nTextIdentity);
    // @TEST-ASSERT
    AssertEquals(Expected := cnTextIdentity_IdentityHigh,
                 Actual := nTextIdentity,
                 Message := 'Test $'TextIdentity#High$' failed');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE WhenTextIdentityLowExpectTextIdentity0
VAR
    fbDiagnosticMessageTextIdentityParser : FB_DiagnosticMessageTextIdentityParser;
    nTextIdentity : UINT;

    // @TEST-FIXTURE TextIdentity#Low
    cnTextIdentityBufferByte1_IdentityLow : BYTE := 16#00; // 0 = no text identity
    cnTextIdentityBufferByte2_IdentityLow : BYTE := 16#00;
    canTextIdentityBuffer_IdentityLow : ARRAY[1..2] OF BYTE := [cnTextIdentityBufferByte1_IdentityLow,
                                                                cnTextIdentityBufferByte2_IdentityLow];
    // @TEST-RESULT TextIdentity#Low
    cnTextIdentity_IdentityLow : UINT := 0;
END_VAR
IF TEST_ORDERED('WhenTextIdentityLowExpectTextIdentity0') THEN
    GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityLowExpectTextIdentity0 := GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityLowExpectTextIdentity0 + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageTextIdentityParser(anTextIdentityBuffer := canTextIdentityBuffer_IdentityLow,
                                          nTextIdentity => nTextIdentity);
    // @TEST-ASSERT
    AssertEquals(Expected := cnTextIdentity_IdentityLow,
                 Actual := nTextIdentity,
                Message := 'Test $'TextIdentity#Low$' failed');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE WhenTextIdentityMedExpectTextIdentity34500
VAR
    fbDiagnosticMessageTextIdentityParser : FB_DiagnosticMessageTextIdentityParser;
    nTextIdentity : UINT;

    // @TEST-FIXTURE TextIdentity#Med
    cnTextIdentityBufferByte1_IdentityMed : BYTE := 16#C4; // 0x86C4 = 34500
    cnTextIdentityBufferByte2_IdentityMed : BYTE := 16#86;
    canTextIdentityBuffer_IdentityMed : ARRAY[1..2] OF BYTE := [cnTextIdentityBufferByte1_IdentityMed,
                                                                cnTextIdentityBufferByte2_IdentityMed];
    // @TEST-RESULT TextIdentity#Med
    cnTextIdentity_IdentityMed : UINT := 34500;
END_VAR
IF TEST_ORDERED('WhenTextIdentityMedExpectTextIdentity34500') THEN
    GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityMedExpectTextIdentity34500 := GVL.fbDiagnosticMessageTextIdentityParser_Test_WhenTextIdentityMedExpectTextIdentity34500 + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageTextIdentityParser(anTextIdentityBuffer := canTextIdentityBuffer_IdentityMed,
                                          nTextIdentity => nTextIdentity);
    // @TEST-ASSERT
    AssertEquals(Expected := cnTextIdentity_IdentityMed,
                 Actual := nTextIdentity,
                 Message := 'Test $'TextIdentity#Med$' failed');

    TEST_FINISHED();
END_IF
END_METHOD

END_FUNCTION_BLOCK
