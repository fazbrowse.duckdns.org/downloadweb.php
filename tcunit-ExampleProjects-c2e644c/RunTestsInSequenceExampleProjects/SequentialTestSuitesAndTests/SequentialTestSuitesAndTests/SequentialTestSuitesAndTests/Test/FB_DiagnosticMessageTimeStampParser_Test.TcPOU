FUNCTION_BLOCK FB_DiagnosticMessageTimeStampParser_Test EXTENDS TcUnit.FB_TestSuite

(* The tests are run in the order that they are called. Asserts are not evaluated before the previous test has called TEST_FINISHED() *)
TestWithTimestampZeroTimeExpectCurrentTime();
TestWithValidTimestampExpectSameTimestamp();

METHOD PRIVATE TestWithTimestampZeroTimeExpectCurrentTime
VAR
    fbDiagnosticMessageTimeStampParser : FB_DiagnosticMessageTimeStampParser;
    sTimeStamp : STRING(29);

    nCurrentDcTaskTime : Tc2_EtherCAT.T_DCTIME64;
    sCurrentDcTaskTimeString : STRING(29);

    // @TEST-FIXTURE time stamp zero time
    canTimeStampBuffer_TimeStampZeroTime : ARRAY[1..8] OF BYTE := [8(16#00)];
END_VAR
IF TEST_ORDERED('TestWithTimestampZeroTimeExpectCurrentTime') THEN
    GVL.fbDiagnosticMessageTimeStampParser_Test_TestWithTimestampZeroTimeExpectCurrentTime := GVL.fbDiagnosticMessageTimeStampParser_Test_TestWithTimestampZeroTimeExpectCurrentTime + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageTimeStampParser(anTimeStampBuffer := canTimeStampBuffer_TimeStampZeroTime,
                                       sTimeStamp => sTimeStamp);
    nCurrentDcTaskTime := Tc2_EtherCAT.F_GetCurDcTaskTime64();
    sCurrentDcTaskTimeString := DCTIME64_TO_STRING(in := nCurrentDcTaskTime);

    // @TEST-ASSERT
    AssertEquals(Expected := sCurrentDcTaskTimeString,
                 Actual := sTimeStamp,
                 Message := 'Test $'TimeStamp zero time$' failed');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE TestWithValidTimestampExpectSameTimestamp
VAR
    fbDiagnosticMessageTimeStampParser : FB_DiagnosticMessageTimeStampParser;
    sTimeStamp : STRING(29);

    // @TEST-FIXTURE TimeStamp valid time
    cnTimeStampBufferByte1_TimeStampValidTime : BYTE := 16#C0; // 0x07C76560A71025C0 = '2017-10-05-14:15:44.425035200'
    cnTimeStampBufferByte2_TimeStampValidTime : BYTE := 16#25;
    cnTimeStampBufferByte3_TimeStampValidTime : BYTE := 16#10;
    cnTimeStampBufferByte4_TimeStampValidTime : BYTE := 16#A7;
    cnTimeStampBufferByte5_TimeStampValidTime : BYTE := 16#60;
    cnTimeStampBufferByte6_TimeStampValidTime : BYTE := 16#65;
    cnTimeStampBufferByte7_TimeStampValidTime : BYTE := 16#C7;
    cnTimeStampBufferByte8_TimeStampValidTime : BYTE := 16#07;
    canTimeStampBuffer_TimeStampValidTime : ARRAY[1..8] OF BYTE := [cnTimeStampBufferByte1_TimeStampValidTime,
                                                                    cnTimeStampBufferByte2_TimeStampValidTime,
                                                                    cnTimeStampBufferByte3_TimeStampValidTime,
                                                                    cnTimeStampBufferByte4_TimeStampValidTime,
                                                                    cnTimeStampBufferByte5_TimeStampValidTime,
                                                                    cnTimeStampBufferByte6_TimeStampValidTime,
                                                                    cnTimeStampBufferByte7_TimeStampValidTime,
                                                                    cnTimeStampBufferByte8_TimeStampValidTime];
    // @TEST-RESULT TimeStamp valid time
    csTimeStamp_TimeStampValidTime : STRING(29) := '2017-10-05-14:15:44.425035200'; // T_DCTime64 = 16#07C76560A71025C0
END_VAR
IF TEST_ORDERED('TestWithValidTimestampExpectSameTimestamp') THEN
    GVL.fbDiagnosticMessageTimeStampParser_Test_TestWithValidTimestampExpectSameTimestamp := GVL.fbDiagnosticMessageTimeStampParser_Test_TestWithValidTimestampExpectSameTimestamp + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageTimeStampParser(anTimeStampBuffer := canTimeStampBuffer_TimeStampValidTime,
                                       sTimeStamp => sTimeStamp);

    // @TEST-ASSERT
    AssertEquals(Expected := csTimeStamp_TimeStampValidTime,
                 Actual := sTimeStamp,
                 Message := 'Test $'TimeStamp zero time$' failed');

    TEST_FINISHED();
END_IF
END_METHOD

END_FUNCTION_BLOCK
