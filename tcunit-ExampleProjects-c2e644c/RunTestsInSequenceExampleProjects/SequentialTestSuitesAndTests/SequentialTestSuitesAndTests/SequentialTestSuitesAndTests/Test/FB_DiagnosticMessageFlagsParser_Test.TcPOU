FUNCTION_BLOCK FB_DiagnosticMessageFlagsParser_Test EXTENDS TcUnit.FB_TestSuite

(* The tests are run in the order that they are called. Asserts are not evaluated before the previous test has called TEST_FINISHED() *)
WhenInfoMessageExpectInfoMessageGlobalTimestampAndZeroParameters();
WhenWarningMessageExpectWarningMessageLocalTimestampAndTwoParameters();
WhenErrorMessageExpectErrorMessageLocalTimestampAndFourParameters();
WhenReservedForFutureUseMessageExpectReservedForFutureUseMessageLocalTimestampAnd33Parameters();

METHOD PRIVATE WhenErrorMessageExpectErrorMessageLocalTimestampAndFourParameters
VAR
    fbDiagnosticMessageFlagsParser : FB_DiagnosticMessageFlagsParser;
    stFlags : ST_FLAGS;

    // @TEST-FIXTURE ErrorMessage
    cnFlagsBufferByte1_ErrorMessage : BYTE := 2#0001_0010; // Error message and local time stamp
    cnFlagsBufferByte2_ErrorMessage : BYTE := 2#0000_0100; // Four parameters in the diagnosis message
    canFlagsBuffer_ErrorMessage : ARRAY[1..2] OF BYTE := [cnFlagsBufferByte1_ErrorMessage, 
                                                          cnFlagsBufferByte2_ErrorMessage];
    // @TEST-RESULT ErrorMessage
    ceFlags_DiagnosisTypeErrorMessage : E_DIAGNOSISTYPE := E_DIAGNOSISTYPE.ErrorMessage;
    ceFlags_TimeStampTypeLocal : E_TIMESTAMPTYPE := E_TIMESTAMPTYPE.Local;
    cnFlags_NumberOfParametersInDiagnosisMessageFour : USINT := 4;
END_VAR
IF TEST_ORDERED('WhenErrorMessageExpectErrorMessageLocalTimestampAndFourParameters') THEN
    GVL.fbDiagnosticMessageFlagsParser_Test_WhenErrorMessageExpectErrorMessageLocalTimestampAndFourParameters := GVL.fbDiagnosticMessageFlagsParser_Test_WhenErrorMessageExpectErrorMessageLocalTimestampAndFourParameters + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN ErrorMessage
    fbDiagnosticMessageFlagsParser(anFlagsBuffer := canFlagsBuffer_ErrorMessage,
                                   stFlags => stFlags);

    // @TEST-ASSERT ErrorMessage
    AssertEquals(Expected := ceFlags_DiagnosisTypeErrorMessage,
                 Actual := stFlags.eDiagnosisType,
                 'Test $'Error message$' failed at $'diagnosis type$'');
    AssertEquals(Expected := ceFlags_TimeStampTypeLocal,
                 Actual := stFlags.eTimeStampType,
                 'Test $'Error message$' failed at $'timestamp type$'');
    AssertEquals(Expected := cnFlags_NumberOfParametersInDiagnosisMessageFour,
                 Actual := stFlags.nNumberOfParametersInDiagnosisMessage,
                 'Test $'Error message$' failed at $'number of parameters$'');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE WhenInfoMessageExpectInfoMessageGlobalTimestampAndZeroParameters
VAR
    fbDiagnosticMessageFlagsParser : FB_DiagnosticMessageFlagsParser;
    stFlags : ST_FLAGS;

    // @TEST-FIXTURE InfoMessage
    cnFlagsBufferByte1_InfoMessage : BYTE := 2#0000_0000; // Info message and global time stamp
    cnFlagsBufferByte2_InfoMessage : BYTE := 2#0000_0000; // Zero parameters in the diagnosis message
    canFlagsBuffer_InfoMessage : ARRAY[1..2] OF BYTE := [cnFlagsBufferByte1_InfoMessage, 
                                                         cnFlagsBufferByte2_InfoMessage];
    // @TEST-RESULT InfoMessage
    ceFlags_DiagnosisTypeInfoMessage : E_DIAGNOSISTYPE := E_DIAGNOSISTYPE.InfoMessage;
    ceFlags_TimeStampTypeGlobal : E_TIMESTAMPTYPE := E_TIMESTAMPTYPE.Global;
    cnFlags_NumberOfParametersInDiagnosisMessageZero : USINT := 0;
END_VAR
IF TEST_ORDERED('WhenInfoMessageExpectInfoMessageGlobalTimestampAndZeroParameters') THEN
    GVL.fbDiagnosticMessageFlagsParser_Test_WhenInfoMessageExpectInfoMessageGlobalTimestampAndZeroParameters := GVL.fbDiagnosticMessageFlagsParser_Test_WhenInfoMessageExpectInfoMessageGlobalTimestampAndZeroParameters + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN
    fbDiagnosticMessageFlagsParser(anFlagsBuffer := canFlagsBuffer_InfoMessage,
                                   stFlags => stFlags);

    // @TEST-ASSERT
    AssertEquals(Expected := ceFlags_DiagnosisTypeInfoMessage,
                 Actual := stFlags.eDiagnosisType,
                 'Test $'Info message$' failed at $'diagnosis type$'');
    AssertEquals(Expected := ceFlags_TimeStampTypeGlobal,
                 Actual := stFlags.eTimeStampType,
                 'Test $'Info message$' failed at $'timestamp type$'');
    AssertEquals(Expected := cnFlags_NumberOfParametersInDiagnosisMessageZero,
                 Actual := stFlags.nNumberOfParametersInDiagnosisMessage,
                 'Test $'Info message$' failed at $'number of parameters$'');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE WhenReservedForFutureUseMessageExpectReservedForFutureUseMessageLocalTimestampAnd33Parameters
VAR
    fbDiagnosticMessageFlagsParser : FB_DiagnosticMessageFlagsParser;
    stFlags : ST_FLAGS;

    // @TEST-FIXTURE ReservedForFutureUseMessage
    cnFlagsBufferByte1_ReservedForFutureUseMessage : BYTE := 2#0001_0011; // ReservedForFutureUse message and local time stamp
    cnFlagsBufferByte2_ReservedForFutureUseMessage : BYTE := 2#0010_0001; // 33 parameters in the diagnosis message
    canFlagsBuffer_ReservedForFutureUseMessage : ARRAY[1..2] OF BYTE := [cnFlagsBufferByte1_ReservedForFutureUseMessage, 
                                                                         cnFlagsBufferByte2_ReservedForFutureUseMessage];
    // @TEST-RESULT ReservedForFutureUseMessage
    ceFlags_DiagnosisTypeReservedForFutureUseMessage : E_DIAGNOSISTYPE := E_DIAGNOSISTYPE.Unspecified;
    cnFlags_NumberOfParametersInDiagnosisMessage33 : USINT := 33;
    ceFlags_TimeStampTypeLocal : E_TIMESTAMPTYPE := E_TIMESTAMPTYPE.Local;
END_VAR
IF TEST_ORDERED('WhenReservedForFutureUseMessageExpectReservedForFutureUseMessageLocalTimestampAnd33Parameters') THEN
    GVL.fbDiagnosticMessageFlagsParser_Test_WhenReservedForFutureUseMessageExpectReservedForFutureUseMessageLocalTimestampAnd33Parameters := GVL.fbDiagnosticMessageFlagsParser_Test_WhenReservedForFutureUseMessageExpectReservedForFutureUseMessageLocalTimestampAnd33Parameters + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN ReservedForFutureUseMessage
    fbDiagnosticMessageFlagsParser(anFlagsBuffer := canFlagsBuffer_ReservedForFutureUseMessage,
                                   stFlags => stFlags);

    // @TEST-ASSERT ReservedForFutureUseMessage
    AssertEquals(Expected := ceFlags_DiagnosisTypeReservedForFutureUseMessage,
                 Actual := stFlags.eDiagnosisType,
                 'Test $'Reserved for future use message$' failed at $'diagnosis type$'');
    AssertEquals(Expected := ceFlags_TimeStampTypeLocal,
                 Actual := stFlags.eTimeStampType,
                 'Test $'Reserved for future use message$' failed at $'timestamp type$'');
    AssertEquals(Expected := cnFlags_NumberOfParametersInDiagnosisMessage33,
                 Actual := stFlags.nNumberOfParametersInDiagnosisMessage,
                 'Test $'Reserved for future use message$' failed at $'number of parameters$'');

    TEST_FINISHED();
END_IF
END_METHOD

METHOD PRIVATE WhenWarningMessageExpectWarningMessageLocalTimestampAndTwoParameters
VAR
    fbDiagnosticMessageFlagsParser : FB_DiagnosticMessageFlagsParser;
    stFlags : ST_FLAGS;

    // @TEST-FIXTURE WarningMessage
    cnFlagsBufferByte1_WarningMessage : BYTE := 2#0001_0001; // Warning message and local time stamp
    cnFlagsBufferByte2_WarningMessage : BYTE := 2#0000_0010; // Two parameters in the diagnosis message
    canFlagsBuffer_WarningMessage : ARRAY[1..2] OF BYTE := [cnFlagsBufferByte1_WarningMessage, 
                                                            cnFlagsBufferByte2_WarningMessage];
    // @TEST-RESULT WarningMessage
    ceFlags_DiagnosisTypeWarningMessage : E_DIAGNOSISTYPE := E_DIAGNOSISTYPE.WarningMessage;
    ceFlags_TimeStampTypeLocal : E_TIMESTAMPTYPE := E_TIMESTAMPTYPE.Local;
    cnFlags_NumberOfParametersInDiagnosisMessageTwo : USINT := 2;
END_VAR
IF TEST_ORDERED('WhenWarningMessageExpectWarningMessageLocalTimestampAndTwoParameters') THEN
    GVL.fbDiagnosticMessageFlagsParser_Test_WhenWarningMessageExpectWarningMessageLocalTimestampAndTwoParameters := GVL.fbDiagnosticMessageFlagsParser_Test_WhenWarningMessageExpectWarningMessageLocalTimestampAndTwoParameters + 1; // Only for testing the framework. Ignore this.

    // @TEST-RUN WarningMessage
    fbDiagnosticMessageFlagsParser(anFlagsBuffer := canFlagsBuffer_WarningMessage,
                                   stFlags => stFlags);

    // @TEST-ASSERT WarningMessage
    AssertEquals(Expected := ceFlags_DiagnosisTypeWarningMessage,
                 Actual := stFlags.eDiagnosisType,
                 'Test $'Warning message$' failed at $'diagnosis type$'');
    AssertEquals(Expected := ceFlags_TimeStampTypeLocal,
                 Actual := stFlags.eTimeStampType,
                 'Test $'Warning message$' failed at $'timestamp type$'');
    AssertEquals(Expected := cnFlags_NumberOfParametersInDiagnosisMessageTwo,
                 Actual := stFlags.nNumberOfParametersInDiagnosisMessage,
                 'Test $'Warning message$' failed at $'number of parameters$'');

    TEST_FINISHED();

END_IF
END_METHOD

END_FUNCTION_BLOCK
